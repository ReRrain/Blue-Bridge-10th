# Keil uVision project 电压显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 电压显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../src/: key.c led.c main.c pcf8591.c i2c.c
  group include
    ../src/: config.h key.h led.h pcf8591.h i2c.h
