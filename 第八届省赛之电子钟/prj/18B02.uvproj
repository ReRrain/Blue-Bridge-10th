# Keil uVision project 18B02.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 18B02 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../src/: ds3102.c key.c ds18b02.c led.c main.c
  group include
    ../src/: config.h ds18b02.h key.h led.h ds1302.h
