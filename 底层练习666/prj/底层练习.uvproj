# Keil uVision project 底层练习.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 底层练习 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51
    ../src/: ds18b20.c ds1302.c e2prom.c i2c.c key.c led.c main.c pcf8591.c
  group include
    ../src/: config.h ds18b20.h ds1302.h e2prom.h i2c.h key.h led.h pcf8591.h
