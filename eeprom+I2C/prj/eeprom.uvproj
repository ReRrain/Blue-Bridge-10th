# Keil uVision project eeprom.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: eeprom +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../src/: eeprom.c i2.c main.c uart.c
  group include
    ../src/: config.h eeprom.h i2.h uart.h
