# Keil uVision project 彩灯模拟器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 彩灯模拟器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../src/: eeprom.c i2.c key.c led.c pcf8591.c main.c
  group include
    ../src/: config.h eeprom.h i2.h key.h led.h pcf8591.h
