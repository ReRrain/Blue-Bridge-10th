# Keil uVision project ds1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../src/: ds3102.c led.c main.c ds18b02.c key.c time.c
  group include
    ../src/: config.h ds1302.h led.h ds18b02.h key.h time.h main.h
