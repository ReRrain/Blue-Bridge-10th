# Keil uVision project 串口.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 串口 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../src/: main.c uart.c
  group include
    ../src/: config.h uart.h
