# Keil uVision project 第十届蓝桥.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 第十届蓝桥 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ../src/: i2c.c key.c led.c main.c pcf8591.c test.c
  group include
    ../src/: config.h i2c.h key.h led.h pcf8591.h main.h test.h
